# Keil uVision project MM32SPIN0280_App.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN0280DAP MindMotion
  pack: MindMotion.MM32SPIN0280_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32SPIN0280_App +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Device\MM32SPIN0280\Source;..\Device\MM32SPIN0280\Include;..\Device\MM32SPIN0280\HAL_Lib\Inc;..\Device\CMSIS\KEIL_Core;..\App;..\App\DELAY;..\App\LED;..\App\SYS;..\App\UART
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000100 size 0x1f00
  group APP
    ../App/: main.c uart_interrupt.c gpio_led_toggle.c mm32spin0280_it.c platform.c
    ../App/SYS/: sys.c
    ../App/DELAY/: delay.c
  group HAL_lib
    ../Device/MM32SPIN0280/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_csm.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group Startup
    ../Device/MM32SPIN0280/Source/: system_mm32spin0280.c
    ../Device/MM32SPIN0280/Source/KEIL_StartAsm/: startup_mm32spin0280_keil.s
